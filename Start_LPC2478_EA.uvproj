# Keil uVision project Start_LPC2478_EA.uvproj, settings and files
target Debug_FLASH_J-Link (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Start_LPC2478_EA
  c flags: Optim=1
  c define: DEBUG=1
  c include: Application\SEGGERDEMO;Application\SEGGERDEMO\Src;Setup;Inc;Config;FS;IP;IP\IP_FS\FS_RO\Generated;GUI;OS;USB;USBH
  asm misc: --diag_suppress A1788W,A1786W
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  scatter file: .\Setup\FLASH.scat
  link misc: --entry __program_start
  group Application
    ./Application/: OS_USBH_HID.c
  group Application\Excluded
    ./Application/: GUI_ALPHA_TransparentDialogDemo.c USB_Printer.c FS_APIValidation.c FS_CheckDisk.c FS_DirOperations.c FS_Performance.c FS_PerformanceSimple.c FS_Start.c FS_Start_ReadWriteHook.c FS_WritePerformanceTest.c GUI_HelloWorld.c GUI_HouseControlDemo.c GUI_IP_ALPHA_TransparentDialogDemo.c GUI_IP_emExplorer.c GUI_IP_HouseControlDemo.c GUI_IP_ReversiDemo.c GUI_IP_WIDGET_GraphXYDemo.c GUI_IP_WIDGET_GraphYtDemo.c GUI_OS_Status.c GUI_ReversiDemo.c GUI_USB_MSD_FS_Start.c GUI_USB_MSD_FS_StartNew.c GUI_WIDGET_GraphXYDemo.c GUI_WIDGET_GraphYtDemo.c OS_IP_DNSClient.c OS_IP_FTPServer.c OS_IP_NonBlockingConnect.c OS_IP_Ping.c OS_IP_SendMail.c OS_IP_Shell.c OS_IP_SimpleServer.c OS_IP_SpeedClient.c OS_IP_SpeedClient_TCP.c OS_IP_SpeedClient_UDP.c OS_IP_Start.c OS_IP_UDPDiscover.c OS_IP_UDPDiscoverZeroCopy.c OS_IP_Webserver.c OS_Main_EVENT.c OS_Main_OS_Q.c OS_Main_TaskEx.c OS_MeasureCST_HRTimer_embOSView.c OS_MeasureCST_HRTimer_Printf.c OS_MeasureCST_Scope.c OS_PerformanceTest.c OS_Start_2Tasks.c OS_Start_LEDBlink.c OS_USBH_HIDManual.c OS_USBH_MSD.c USB_BULK_Echo1.c USB_BULK_Echo1_Timed.c USB_BULK_EchoFast.c USB_Bulk_Sample.c USB_BULK_ShowDeviceState.c USB_BULK_Test.c USB_CDC_Echo.c USB_CDC_Start.c USB_CompositeDevice_CDC_MSD.c USB_CompositeDevice_HID_Echo1_MSD.c USB_HID_Echo1.c USB_HID_Mouse.c USB_MSD_CDROM_Start.c USB_MSD_FS_DisconnectOnWrite.c USB_MSD_FS_Start.c USB_MSD_FS_WriteOnDisconnect.c USB_MSD_Start_StorageByName.c USB_MSD_Start_StorageRAM.c
  group Setup
    ./Setup/: Vectors.s BSP.c Debug_FLASH_J-Link.ini Debug_FLASH_ULINK.ini FLASH.scat FS_ConfigRAMDisk.c GUI_Weak.c IP_Config_LPC24xx.c Release_FLASH.ini Retarget.c Startup_LPC2xxx.s USB_Config_LPC2468_EA.c USBH_Config_LPC24xx.c I2CPCA9532.c RTOSInit.c GUI_X_Touch.c GUIConf.c
  group Config
    ./Config/: WEBS_Conf.h FS_Conf.h FS_ConfigIO.c FTPS_Conf.h GUIConf.h IP_Conf.h IP_ConfigIO.c LCDConf.h OS_Config.h SMTPC_Conf.h SysConf.h USB_Conf.h USBH_Conf.h USBH_ConfigIO.c
  group FS
    ./FS/: NOR_Private.h EFS.h EFS_Intern.h FAT.h FAT_Intern.h FS.h FS_4t_tl_id_trial.lib FS_4t_tl_ir_trial.lib FS_API.h FS_CLib.h FS_ConfDefaults.h FS_Debug.h FS_Dev.h FS_DF_X_HW.h FS_Int.h FS_Lbl.h FS_OS.h FS_Storage.h FS_Types.h FS_X_embOS.c IDE_X_HW.h MMC_MCI_HW.h MMC_SD_CardMode_X_HW.h MMC_X_HW.h NAND_X_HW.h NOR_HW_SPI_X.h
  group GUI
    ./GUI/: WM_Intern_ConfDep.h BUTTON.h BUTTON_Private.h CHECKBOX.h CHECKBOX_Private.h DIALOG.h DIALOG_Intern.h DROPDOWN.h DROPDOWN_Private.h EDIT.h EDIT_Private.h FRAMEWIN.h FRAMEWIN_Private.h Global.h GRAPH.h GRAPH_Private.h GUI.h GUI_ARRAY.h GUI_ARRAY_Private.h GUI_BMP_Private.h GUI_ConfDefaults.h GUI_Debug.h GUI_FontIntern.h GUI_GIF_Private.h GUI_HOOK.h GUI_JPEG_Private.h GUI_Private.h GUI_Type.h GUI_Version.h GUI_VNC.h GUI_VNC_X_StartServer.c GUI_X_embOS.c GUIDRV_Generic.h GUIv5_4t_tl_i_trial.lib HEADER.h HEADER_Private.h ICONVIEW.h ICONVIEW_Private.h LCD.h LCD_ConfDefaults.h LCD_Private.h LCD_Protected.h LCD_SIM.h LISTBOX.h LISTBOX_Private.h LISTVIEW.h LISTVIEW_Private.h LISTWHEEL.h LISTWHEEL_Private.h MENU.h MENU_Private.h MESSAGEBOX.h MULTIEDIT.h MULTIPAGE.h MULTIPAGE_Private.h PROGBAR.h PROGBAR_Private.h RADIO.h RADIO_Private.h SCROLLBAR.h SCROLLBAR_Private.h SLIDER.h SLIDER_Private.h TEXT.h TEXT_Private.h TREEVIEW.h TREEVIEW_Private.h WIDGET.h WINDOW_Private.h WM.h WM_GUI.h WM_Intern.h
  group Inc
    ./Inc/: Util.h BSP.h JLINKDCC.h SEGGER.h Taskprio.h
  group IP
    ./IP/: IP_Webserver.h IP.h IP_4t_tl_id_trial.lib IP_4t_tl_ir_trial.lib IP_ConfDefaults.h IP_FS.h IP_FTPServer.h IP_ICMP.h IP_Int.h IP_mbuf.h IP_NI_NIOSII_More10IP_A2A.h IP_NI_STM32F107.h IP_protosw.h IP_Q.h IP_SMTPC.h IP_socket.h IP_sockvar.h IP_TCP.h IP_TCP_pcb.h IP_UTIL.h
  group IP\IP_FS\emFile
    ./IP/IP_FS/emFile/: IP_FS_FS.c
  group IP\IP_FS\FS_RO\
    ./IP/IP_FS/FS_RO/: FS_RO.c
  group IP\IP_FS\FS_RO\Generated
    ./IP/IP_FS/FS_RO/Generated/: Stats.h About.c About.h Authen.c Authen.h bg.c bg.h CallVirtualFile.c CallVirtualFile.h embOS.c embOS.h favicon.c favicon.h FormsGET.c FormsGET.h FormsPOST.c FormsPOST.h Index.c Index.h Segger.c SeggerLogo.c SeggerLogo.h SendviaSMTP.c SendviaSMTP.h Stats.c
  group OS
    ./OS/: OS_Error.c Main.c osT4LR_trial.lib osT4LDP_trial.lib
  group USB
    ./USB/: USB_Private.h USB.h USB_4t_tl_id_trial.lib USB_4t_tl_ir_trial.lib USB_CDC.h USB_CDC_Private.h USB_HID.h USB_HID_Private.h USB_MSD.h USB_MSD_Private.h USB_OS_embOS.c
  group Util
    ./Util/: JLINKDCC_Process.c JLINKDCC_HandleDataAbort.s JLINKDCC_Process_ASM.s SEGGER_ARM_memcpy_MDK.s
  group USBH
    ./USBH/: USBH_Int.h USBH.h USBH_4t_tl_id_trial.lib USBH_4t_tl_ir_trial.lib USBH_ConfDefaults.h
target Release_FLASH_J-Link (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: as above
  output: Start_LPC2478_EA +hex
  c flags: Optim=4
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  scatter file: .\Setup\FLASH.scat
  link misc: --entry __program_start
target Debug_FLASH_ULINK (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: as above
  output: Start_LPC2478_EA
  c flags: Optim=1
  c define: DEBUG=1
  c include: Application\SEGGERDEMO,Application\SEGGERDEMO\Src,Setup,Inc,Config,FS,IP,IP\IP_FS\FS_RO\Generated,GUI,OS,USB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  scatter file: .\Setup\FLASH.scat
  link misc: --entry __program_start
target Release_FLASH_ULINK (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: as above
  output: Start_LPC2478_EA +hex
  c flags: Optim=4
  c include: as above
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  scatter file: .\Setup\FLASH.scat
  link misc: --entry __program_start
